## drivers/net/wireless/realtek/rtl8812au/Kconfig
```kconfig
config 88XXAU
	bool "Realtek 88XXau USB WiFi"
	default y
	help
	  Help message of 88XXau
```
